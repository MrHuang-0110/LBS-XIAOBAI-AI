# Keil uVision project XiaoBai.uvprojx, settings and files
target PY32F030_Project (5060960::V5.06 update 7 (build 960)::.\version5.06)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: XiaoBai +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x6
  c include: ..\User;..\CMSIS\Include;..\CMSIS\Device\PY32F0xx\Include;..\PY32F0xx_HAL_Driver\Inc;..\BSP_Drivers;..\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ../CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f030x6.s
    ../User/: system_py32f0xx.c
  group Application/User
    ../User/: main.c py32f0xx_it.c py32f0xx_hal_msp.c App_System.c App_Vehicle.c App_Mode.c App_Mode_Power.c App_Mode_Sensor.c App_Mode_Remote.c App_Mode_Voice.c App_Eye.c App_Breath.c App_Shutdown.c App_Battery.c App_Main.c App_Program.c App_Display.c Eye_Data.c
  group PY32F0xx_HAL_Driver
    ../PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group Bsp_Drivers
    ../BSP_Drivers/: Bsp.c
    ../BSP_Drivers/Bsp_Tick/: Bsp_Tick.c
    ../BSP_Drivers/Bsp_Led/: Bsp_Led.c
    ../BSP_Drivers/Bsp_Power/: Bsp_Power.c
    ../BSP_Drivers/Bsp_Motor/: Bsp_Motor.c
    ../BSP_Drivers/Bsp_LedPwm/: Bsp_LedPwm.c
    ../BSP_Drivers/Bsp_Key/: Bsp_Key.c
    ../BSP_Drivers/Bsp_UartAsr/: Bsp_UartAsr.c
    ../BSP_Drivers/Bsp_UartBle/: Bsp_UartBle.c
    ../BSP_Drivers/Bsp_Adc/: Bsp_Adc.c
    ../BSP_Drivers/Bsp_IR/: Bsp_IR.c
    ../BSP_Drivers/Bsp_Battery/: Bsp_Battery.c
    ../BSP_Drivers/Bsp_Tm1640/: Bsp_Tm1640.c
  group Protocol
    ../Protocol/: Proto_Asr.c Proto_Ble.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.1.2
